inherit maven

# Files Maven writes into the local repository that are not dependencies.
MAVEN_UPDATE_DEPS_IGNORE = "\
    .lastUpdated \
    .md5 \
    .repositories \
    .sha1 \
    _remote.repositories \
    maven-metadata-central.xml \
    resolver-status.properties \
"

def maven_update_deps_env(d):
    import os

    env = dict(os.environ)
    env["JAVA_HOME"] = d.getVar("MAVEN_JAVA_HOME")
    env["M2_HOME"] = d.getVar("MAVEN_HOME")
    env["MAVEN_HOME"] = d.getVar("MAVEN_HOME")
    return env

def maven_update_deps_run(d, maven_repo, *args):
    """Run mvn against maven_repo and return the URLs it downloaded."""
    import os
    import re
    import subprocess

    cmd = [
        os.path.join(d.getVar("MAVEN_HOME"), "bin", "mvn"),
        *args,
        "--batch-mode",
        f"-Dmaven.repo.local={maven_repo}",
        "-f", d.getVar("S"),
        *d.getVar("MAVEN_DEBUG_ARGS").split(),
    ]
    bb.note(f"Running: {' '.join(cmd)}")

    result = subprocess.run(cmd, env=maven_update_deps_env(d), text=True,
                            stdout=subprocess.PIPE, stderr=subprocess.STDOUT)
    urls = []
    for line in result.stdout.splitlines():
        bb.debug(1, line)
        if match := re.search(r"Downloaded from \S+: (https?://\S+)", line):
            urls.append(match.group(1))

    if result.returncode != 0:
        bb.fatal(f"Maven failed ({result.returncode}): {' '.join(cmd)}")
    return urls

def maven_update_deps_collect(d, maven_repo, urls):
    """Match each file in maven_repo to the URL it was downloaded from.
    Returns the SRC_URI entries and their checksums."""
    import hashlib
    import os

    ignore = tuple(d.getVar("MAVEN_UPDATE_DEPS_IGNORE").split())
    bp = d.getVar("BP")
    src_uris = []
    checksums = []

    for root, dirs, files in os.walk(maven_repo):
        # Maven Resolver stores repository filter metadata such as
        # prefixes-central.txt here. It is not a build dependency.
        if root == maven_repo and ".meta" in dirs:
            dirs.remove(".meta")

        for file in files:
            if file.endswith(ignore):
                continue

            full_path = os.path.join(root, file)
            rel_path = os.path.relpath(full_path, maven_repo)

            # Files with the same name can come from different paths, e.g.
            # com/github/jeluard/oss-parent/9/oss-parent-9.pom and
            # org/sonatype/oss/oss-parent/9/oss-parent-9.pom,
            # so match on the full repository path.
            url = next((u for u in urls if u.endswith("/" + rel_path)), None)
            if url is None:
                bb.warn(f"Could not find {rel_path} in mvn output!")
                continue

            with open(full_path, "rb") as f:
                sha256 = hashlib.file_digest(f, "sha256").hexdigest()

            name = rel_path.replace("/", "_")
            src_uris.append(f"{url};name={name};downloadfilename=maven-repo/{bp}/{rel_path}")
            checksums.append(f'SRC_URI[{name}.sha256sum] = "{sha256}"')

    return src_uris, checksums

def maven_update_deps_write_inc(path, extra_vars, src_uris, checksums):
    with open(path, "w") as f:
        f.write("# Auto-generated by maven_update_deps.bbclass; DO NOT EDIT\n\n")
        for name, value in extra_vars.items():
            f.write(f'{name} = "{value}"\n\n')
        f.write('SRC_URI += "\\\n')
        f.writelines(f"    {uri} \\\n" for uri in src_uris)
        f.write('"\n\n')
        f.writelines(f"{checksum}\n" for checksum in checksums)

python do_maven_update_deps() {
    import os
    import shlex
    import shutil

    maven_repo = os.path.join(d.getVar("WORKDIR"), "temp-m2-repo")
    inc_file = os.path.join(d.getVar("THISDIR"), f"{d.getVar('BPN')}-deps.inc")
    plugin = d.getVar("MAVEN_DEPENDENCY_PLUGIN")
    extra_vars: dict[str, str] = {}

    # Files left over from a previous run are not re-downloaded, so they would
    # be missing from the mvn output and silently dropped from the inc file.
    shutil.rmtree(maven_repo, ignore_errors=True)

    # go-offline uses its own resolution, which ignores <exclusions> and can
    # therefore pick different versions than a real build.
    # Running the same goals as do_compile afterwards fetches whatever is missing.
    urls = maven_update_deps_run(d, maven_repo, f"{plugin}:go-offline")
    if bb.data.inherits_class("maven_ptest", d):
        urls += maven_ptest_fetch_junit_console(d, maven_repo, extra_vars)
    urls += maven_update_deps_run(d, maven_repo, *shlex.split(d.getVar("MAVEN_BUILD_FLAGS")))
    maven_update_deps_run(d, maven_repo, "clean")

    src_uris, checksums = maven_update_deps_collect(d, maven_repo, urls)
    maven_update_deps_write_inc(inc_file, extra_vars, src_uris, checksums)
    bb.plain(f"Successfully generated dependency include file: {inc_file}")
}
addtask do_maven_update_deps after do_patch
# nooelint: oelint.task.network - This task only runs when directly called
do_maven_update_deps[network] = "1"
do_maven_update_deps[nostamp] = "1"
do_maven_update_deps[depends] = "maven-bin-native:do_populate_sysroot openjdk-bin-native:do_populate_sysroot"
do_maven_update_deps[doc] = "pre-download and create a deps.inc file. Much like cargo."

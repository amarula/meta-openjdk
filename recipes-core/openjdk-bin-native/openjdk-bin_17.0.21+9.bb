require openjdk-bin.inc

LIC_FILES_CHKSUM:append = "\
    file://jdk-${PV}/legal/java.prefs/ASSEMBLY_EXCEPTION;md5=d94f7c92ff61c5d3f8e9433f76e39f74 \
"
SRC_URI[sha256sum] = "8b9b611d917e3dfd8419d3566b5949226f69b052fed7e109c1368add1dfe8711"

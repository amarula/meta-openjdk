require openjdk-bin.inc

LIC_FILES_CHKSUM:append = "\
    file://jdk-${PV}/legal/java.prefs/ASSEMBLY_EXCEPTION;md5=d54e5b1b11ce92d8abc22e8e756f54bd \
"
SRC_URI[sha256sum] = "68982529869257d0ee6b824ec5aa270ff8b118bb438670da0b97ebdab178d7fb"

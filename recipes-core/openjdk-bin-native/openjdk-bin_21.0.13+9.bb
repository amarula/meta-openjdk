require openjdk-bin.inc

LIC_FILES_CHKSUM:append = "\
    file://jdk-${PV}/legal/java.prefs/ASSEMBLY_EXCEPTION;md5=d54e5b1b11ce92d8abc22e8e756f54bd \
"

SRC_URI[sha256sum] = "d7f5d5cf865a2902b70ff549b97586a7d3f234e016f041ab447ea740c7d66d1c"

require openjdk-bin.inc

LIC_FILES_CHKSUM:append = "\
    file://jdk-${PV}/legal/java.prefs/ASSEMBLY_EXCEPTION;md5=d54e5b1b11ce92d8abc22e8e756f54bd \
"

SRC_URI[sha256sum] = "bb8a93f9ae6e7a693b2b721e85dbeff26ae1a77447985a8d7afcdd9c7cf6222e"

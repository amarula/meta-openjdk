require openjdk-bin.inc

LIC_FILES_CHKSUM:append = "\
    file://jdk-${PV}/legal/java.prefs/ASSEMBLY_EXCEPTION;md5=d54e5b1b11ce92d8abc22e8e756f54bd \
"
SRC_URI[sha256sum] = "005e57ee860978acfeeff1be2b30f770664fe2b941e9b803c61c76992086d107"

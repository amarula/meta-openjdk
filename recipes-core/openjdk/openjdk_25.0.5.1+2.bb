require openjdk-common.inc

SRC_BRANCH = "jdk25.0.5.1"
SRCREV = "d748fac9683a445a8d76c40f132a83604df82efb"

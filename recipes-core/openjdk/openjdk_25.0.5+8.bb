require openjdk-common.inc

SRCREV = "fda231468e56663992785ec199a6efb8eca3cc7a"

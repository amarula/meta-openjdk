require openjdk-common.inc

SRC_BRANCH = "jdk27.0.1.1"
SRCREV = "03d8fb0da157ce832839b05c99f2c9f78de25cb8"


require openjdk-common.inc

SRCREV = "360190464fafe7f6dc53b87304aef715b8d96920"
SRC_BRANCH = "jdk27.0.1.0.2"
